## sdkconfig.defaults
```kconfig
# Enable bluetooth

CONFIG_BT_ENABLED=y
CONFIG_BT_BLE_50_FEATURES_SUPPORTED=y
CONFIG_BT_BLE_42_FEATURES_SUPPORTED=y

CONFIG_BT_LE_50_FEATURE_SUPPORT=n
```
